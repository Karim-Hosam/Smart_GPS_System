# Keil uVision project GPS_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_Project
  c flags: Optim=1
  c define: PART_TM4C123GH6PM
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.2.0.295;C:\ti\TivaWare_C_Series-2.2.0.295\driverlib;C:\ti\TivaWare_C_Series-2.2.0.295\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./Services - Utilities/: bit_utilies.h TM4C123.h system_TM4C123.c startup_TM4C123.s
    ./Second Milestone (Final)/App/: App.c App.h
    ./Second Milestone (Final)/MCAL/GPIO/: GPIO.c GPIO.h
    ./Second Milestone (Final)/MCAL/SYSTICK/: SYSTICK.c SYSTICK.h
    ./Second Milestone (Final)/MCAL/UART/: UART.c UART.h
    ./Second Milestone (Final)/HAL/GPS/: GPS.c GPS.h
    ./Second Milestone (Final)/HAL/LCD/: LCD.c LCD.h
    ./Second Milestone (Final)/HAL/LED_BUZZER/: LED_BUZZER.c LED_BUZZER.h
    ./Second Milestone (Final)/MCAL/TIMER/: TIMER.c TIMER.h
    ./Second Milestone (Final)/HAL/SWITCH_BTN/: SWITCH_BTN.h SWITCH_BTN.c
