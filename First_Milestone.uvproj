# Keil uVision project First_Milestone.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: First_Milestone
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    C:/1- Local Disk (D;)/Karim/1-Study/Junior (2nd Semester)/4- Introduction to Embedded Systems/Project/Smart_GPS_System_FINAL/Smart_GPS_System/First Milestone/App/: App.c App.h
    C:/1- Local Disk (D;)/Karim/1-Study/Junior (2nd Semester)/4- Introduction to Embedded Systems/Project/Smart_GPS_System_FINAL/Smart_GPS_System/First Milestone/MCAL/GPIO/: GPIO.c GPIO.h
    C:/1- Local Disk (D;)/Karim/1-Study/Junior (2nd Semester)/4- Introduction to Embedded Systems/Project/Smart_GPS_System_FINAL/Smart_GPS_System/First Milestone/MCAL/UART/: UART.c UART.h
    C:/1- Local Disk (D;)/Karim/1-Study/Junior (2nd Semester)/4- Introduction to Embedded Systems/Project/Smart_GPS_System_FINAL/Smart_GPS_System/First Milestone/MCAL/SYSTICK/: SYSTICK.c SYSTICK.h
    C:/1- Local Disk (D;)/Karim/1-Study/Junior (2nd Semester)/4- Introduction to Embedded Systems/Project/Smart_GPS_System_FINAL/Smart_GPS_System/Services - Utilities/: startup_TM4C123.s system_TM4C123.c bit_utilies.h TM4C123.h
